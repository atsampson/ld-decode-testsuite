options:
  parameters:
    generate_options: qt_gui
    id: top_block
    output_language: python
  states: {}

blocks:
- name: analog_dev
  id: variable
  parameters:
    value: '150000'
  states: {}
- name: analog_l_f
  id: variable
  parameters:
    value: '683593.75'
  states: {}
- name: analog_r_f
  id: variable
  parameters:
    value: '1066406.25'
  states: {}
- name: analog_rate
  id: variable
  parameters:
    value: '400000'
  states: {}
- name: analog_taps
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: '100000'
    gain: '1.0'
    samp_rate: samp_rate
    width: '50000'
    win: firdes.WIN_HAMMING
  states: {}
- name: digital_rate
  id: variable
  parameters:
    value: 4e6
  states: {}
- name: hpf_cutoff
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: 0.05e6
    step: '1'
    stop: 4.0e6
    value: 0.3e6
  states: {}
- name: hpf_trans
  id: variable_qtgui_range
  parameters:
    label: HPF transition
    orient: Qt.Horizontal
    start: 0.05e6
    step: '1'
    stop: 2.0e6
    value: 0.6e6
  states: {}
- name: samp_per_sym
  id: variable
  parameters:
    value: samp_rate/4321800
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '40000000'
  states: {}
- name: analog_fm_demod_cf_0
  id: analog_fm_demod_cf
  parameters:
    audio_decim: '1'
    audio_pass: '20000'
    audio_stop: '22050'
    chan_rate: analog_rate
    deviation: analog_dev
    gain: '1.0'
    tau: '75e-6'
  states: {}
- name: analog_fm_demod_cf_1
  id: analog_fm_demod_cf
  parameters:
    audio_decim: '1'
    audio_pass: '20000'
    audio_stop: '22050'
    chan_rate: analog_rate
    deviation: analog_dev
    gain: '1.0'
    tau: '75e-6'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /var/tmp/digital.s16
    type: short
  states: {}
- name: blocks_file_sink_1
  id: blocks_file_sink
  parameters:
    file: /var/tmp/symbols.b
    type: byte
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /d/extra/laserdisc/audio/fawlty.s16
    length: 10*samp_rate
    repeat: 'False'
    type: short
  states: {}
- name: blocks_float_to_char_0
  id: blocks_float_to_char
  parameters:
    scale: '127'
  states: {}
- name: blocks_float_to_short_0
  id: blocks_float_to_short
  parameters:
    scale: '32767'
  states: {}
- name: blocks_short_to_float_0
  id: blocks_short_to_float
  parameters:
    scale: '32767'
  states: {}
- name: blocks_wavfile_sink_1
  id: blocks_wavfile_sink
  parameters:
    bits_per_sample: '16'
    file: /var/tmp/analog.wav
    nchan: '2'
    samp_rate: analog_rate
  states: {}
- name: digital_clock_recovery_mm_xx_0
  id: digital_clock_recovery_mm_xx
  parameters:
    gain_mu: '0.175'
    gain_omega: 0.25*0.175*0.175
    mu: '0.5'
    omega: samp_per_sym*(1+0.0)
    omega_relative_limit: '0.01'
    type: float
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: analog_l_f
    decim: int(samp_rate/analog_rate)
    samp_rate: samp_rate
    taps: analog_taps
    type: fcc
  states: {}
- name: freq_xlating_fir_filter_xxx_1
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: analog_r_f
    decim: int(samp_rate/analog_rate)
    samp_rate: samp_rate
    taps: analog_taps
    type: fcf
  states: {}
- name: high_pass_filter_0
  id: high_pass_filter
  parameters:
    cutoff_freq: hpf_cutoff
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: hpf_trans
    win: firdes.WIN_HAMMING
  states: {}
- name: iir_filter_xxx_0
  id: iir_filter_xxx
  parameters:
    fbtaps: '[1.0, -5.531249685785423, 12.870330983587246, -16.117383799471483, 11.45268065749906, -4.377155685469766, 0.7028507053198295]'
    fftaps: '[0.003586020165875817, -0.01719881051427781, 0.03757708165257373, -0.04785789117887906, 0.037577081652573716, -0.017198810514277803, 0.0035860201658758145]'
    oldstyle: 'False'
    type: ffd
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '4096'
    freqhalf: 'False'
    grid: 'True'
    name: '"RF"'
    type: float
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_freq_sink_x_1_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '4096'
    freqhalf: 'False'
    grid: 'True'
    name: '"EFM"'
    type: float
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    name: '"RF"'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    name: '"EFM"'
    size: '2048'
    srate: samp_rate
    type: float
  states: {}

connections:
- [analog_fm_demod_cf_0, '0', blocks_wavfile_sink_1, '0']
- [analog_fm_demod_cf_1, '0', blocks_wavfile_sink_1, '1']
- [blocks_file_source_0, '0', blocks_short_to_float_0, '0']
- [blocks_float_to_char_0, '0', blocks_file_sink_1, '0']
- [blocks_float_to_short_0, '0', blocks_file_sink_0, '0']
- [blocks_short_to_float_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [blocks_short_to_float_0, '0', freq_xlating_fir_filter_xxx_1, '0']
- [blocks_short_to_float_0, '0', high_pass_filter_0, '0']
- [blocks_short_to_float_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_short_to_float_0, '0', qtgui_time_sink_x_0, '0']
- [digital_clock_recovery_mm_xx_0, '0', blocks_float_to_char_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', analog_fm_demod_cf_0, '0']
- [freq_xlating_fir_filter_xxx_1, '0', analog_fm_demod_cf_1, '0']
- [high_pass_filter_0, '0', iir_filter_xxx_0, '0']
- [iir_filter_xxx_0, '0', blocks_float_to_short_0, '0']
- [iir_filter_xxx_0, '0', digital_clock_recovery_mm_xx_0, '0']
- [iir_filter_xxx_0, '0', qtgui_freq_sink_x_1_0, '0']
- [iir_filter_xxx_0, '0', qtgui_time_sink_x_1, '0']

metadata:
  file_format: 1
